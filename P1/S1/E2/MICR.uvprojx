# Keil uVision project MICR.uvprojx, settings and files
target Cortex-M0 (5060960::V5.06 update 7 (build 960)::..\ARM_Compiler_5.06u7)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Cortex_M0
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: Cortex_M0.sct
  link misc: --entry Reset_Handler
  group ASM Sources
    ./: asm.s
